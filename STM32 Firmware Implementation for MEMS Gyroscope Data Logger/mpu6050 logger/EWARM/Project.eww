<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\mpu6050 logger.ewp</path>
  </project>
  <batchBuild />
</workspace>
